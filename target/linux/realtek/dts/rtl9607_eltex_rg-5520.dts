// SPDX-License-Identifier: GPL-2.0-or-later OR MIT

/dts-v1/;

#include "rtl960x.dtsi"
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/input/input.h>
#include <dt-bindings/leds/common.h>

/ {
	compatible = "eltex,rg-5520", "realtek,rtl9607c-soc";

	model = "Eltex RG-5520";
#if 0
	aliases {
		label-mac-device = &gmac0;
	};
#endif
};

&chosen {
	bootargs = "earlycon root=254:0";
	mangle-bootargs-0 = "root=31:8", "ubi.block=0,ubi_r0";
	mangle-bootargs-1 = "root=31:10", "ubi.block=0,ubi_r1";
};

#if 0
&gmac0 {
	nvmem-cells = <&macaddr_factory 0>;
	nvmem-cell-names = "mac-address";
};
#endif

&ecc0 {
	status = "okay";
};

&snand {
	status = "okay";

	flash@0 {
		// TODO enable x2/x4
		compatible = "spi-nand";
		reg = <0>;

		nand-ecc-engine = <&ecc0>;
		nand-ecc-strength = <6>;
		nand-ecc-step-size = <512>;
		nand-ecc-algo = "bch";
		nand-ecc-placement = "oob";

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "u-boot";
				reg = <0x0 0xc0000>;
				read-only;
			};

			partition@c0000 {
				label = "factory";
				reg = <0xc0000 0x20000>;
				read-only;
#if 0
				nvmem-layout {
					compatible = "fixed-layout";
					#address-cells = <1>;
					#size-cells = <1>;

					macaddr_factory: macaddr@64 {
						compatible = "mac-base";
						reg = <0x64 0x11>;
						#nvmem-cell-cells = <1>;
					};
				};
#endif
			};

			partition@e0000 {
				compatible = "u-boot,env-redundant-count";
				label = "u-boot-env";
				reg = <0xe0000 0x20000>;
			};

			partition@100000 {
				compatible = "u-boot,env-redundant-count";
				label = "u-boot-env2";
				reg = <0x100000 0x20000>;
			};

			partition@120000 {
				compatible = "linux,ubi";
				label = "ubi";
				reg = <0x120000 0x7940000>;
			};

			partition@140000 {
				label = "mtdoops";
				reg = <0x7a40000 0x200000>;
				read-only;
			};
		};
	};
};

&mdio_ctrl {
	PHY_C22(0, 0)
	PHY_C22(1, 1)
	PHY_C22(2, 2)
	PHY_C22(3, 3)
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT(0, 4, internal)
		SWITCH_PORT(1, 3, internal)
		SWITCH_PORT(2, 2, internal)
		SWITCH_PORT(3, 1, internal)
	};
};

&pcie0 {
	status = "okay";
};

&pcie1 {
	status = "okay";
};
